<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SX1280_L476RG_DemoApp.ewp</path>
  </project>
  <batchBuild />
</workspace>
