# IAR project SX1280_L476RG_DemoApp.ewp, settings and files
configuration SX1280_L476RG_DemoApp (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../SMTC_Drivers/hw-hal/inc; ../SMTC_Drivers/sx1280-driver-c; ../SMTC_Drivers; ../SMTC_App; ../SMTC_Drivers/peripherals/rf_switch; ../SMTC_Drivers/DemoApp/Demo ranging; ../SMTC_Drivers/peripherals/sx9306
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SX1280_L476RG_DemoApp.hex
  ILINK.IlinkOutputFile: SX1280_L476RG_DemoApp.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: gpio.c i2c.c lptim.c main.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c usart.c
    ../SMTC_App/: main_pingpong.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/rf-switch
    ../SMTC_Drivers/peripherals/rf_switch/: rf_switch_cg2214m6.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/sx1280-driver-c
    ../SMTC_Drivers/sx1280-driver-c/: sx1280-hal.c sx1280.c
  group Drivers/sx9360
    ../SMTC_Drivers/peripherals/sx9306/: sx9306.c
  group hw-hal
    ../SMTC_Drivers/hw-hal/src/: hw-gpio.c hw-i2c.c hw-lptim.c hw-spi.c hw-usart.c hw.c
