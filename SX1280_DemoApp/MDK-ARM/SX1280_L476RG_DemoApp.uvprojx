# Keil uVision project SX1280_L476RG_DemoApp.uvprojx, settings and files
target SX1280_L476RG_DemoApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SX1280_L476RG_DevTemplate +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;   ../Drivers/CMSIS/Include;   ..\SMTC_Drivers\hw-hal\inc;   ..\SMTC_Drivers\sx1280-driver-c;   ..\SMTC_Drivers;   ..\SMTC_App;   ..\SMTC_Drivers\peripherals\rf_switch;   ..\SMTC_Drivers\DemoApp\Demo ranging;   ..\SMTC_Drivers\peripherals\sx9306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group App
    ../SMTC_App/: main_pingpong.c main_ranging.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group rf-switch
    ../SMTC_Drivers/peripherals/rf_switch/: rf_switch_cg2214m6.c
  group sx9306
    ../SMTC_Drivers/peripherals/sx9306/: sx9306.c
  group demo ranging
    ../SMTC_Drivers/DemoApp/Demo ranging/: demoRanging.c RangingDisplay.c
  group sx1280-driver-c
    ../SMTC_Drivers/sx1280-driver-c/: sx1280.c sx1280-hal.c
  group hw-hal
    ../SMTC_Drivers/hw-hal/src/: hw-spi.c hw-gpio.c hw.c hw-usart.c hw-i2c.c hw-lptim.c
  group Application/User
    ../Src/: main.c gpio.c i2c.c lptim.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.3.0
